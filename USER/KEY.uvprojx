# Keil uVision project KEY.uvprojx, settings and files
target Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KEY +hex
  c flags: Optim=1 oTime=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\EXTI;..\HARDWARE\INCLUDE;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\SYS_INIT;..\HARDWARE\SPI;..\HARDWARE\LCD;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM\iap;..\APP;..\HARDWARE\SD_CARD;..\HARDWARE\EEPROM;..\HARDWARE\BSP;..\HARDWARE\W25Q64;..\FATFS\option;..\FATFS;..\FONTSHOW;..\MALLOC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xdfff
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SYS_INIT/: sys_init.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/LCD/: ili93xx.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/SD_CARD/: sd.c
    ../HARDWARE/W25Q64/: w25q64.c
    ../HARDWARE/EEPROM/: eeprom.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/iap/: iap.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group STLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_flash.c misc.c
  group FATFS
    ../FATFS/: diskio.c ff.c Fat_API.c
    ../FATFS/option/: cc936.c
  group FONTSHOW
    ../FONTSHOW/: fontshow.c updatefont.c
  group MALLOC
    ../MALLOC/: malloc.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.0.0
